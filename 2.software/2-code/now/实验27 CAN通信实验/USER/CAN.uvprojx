# Keil uVision project CAN.uvprojx, settings and files
target CAN (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: CAN +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\sys;..\SYSTEM\exit;..\SYSTEM\usart;..\SYSTEM\usart2;..\SYSTEM\usart3;..\SYSTEM\delay;..\SYSTEM\rtc;..\FWLIB\inc;..\MALLOC;..\FATFS;..\FATFS\option;..\HARDWARE\CAN;..\HARDWARE\CANdevice;..\HARDWARE\SD;..\HARDWARE\COMscreen;..\HARDWARE\ATK-M750;..\HARDWARE\USART2;..\USER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/exit/: exit.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/usart2/: usart2.c
    ../SYSTEM/usart3/: usart3.c
    ../SYSTEM/rtc/: rtc.c
  group MALLOC
    ../MALLOC/: malloc.c queue.c queue2.c
  group FATFS
    ../FATFS/: diskio.c ff.c
    ../FATFS/option/: cc936.c
  group HARDWARE
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/CANdevice/: CANdevice.c CANdevice3402.c CANdevice4055.c CANdevice5801.c CANdevice7017.c
    ../HARDWARE/SD/: sdio_sdcard.c SDCardFile.c
    ../HARDWARE/COMscreen/: COMscreen.c COMscreen_drive.c
    ../HARDWARE/ATK-M750/: atk_m750.c
  group USER
    ./: main.c translate.c stm32f4xx_it.c system_stm32f4xx.c
  group README
    ../: readme.txt
